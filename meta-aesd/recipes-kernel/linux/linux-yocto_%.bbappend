FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://faulty.cfg"